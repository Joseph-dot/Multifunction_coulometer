# Keil uVision project STM32F407VG.uvprojx, settings and files
target STM32F407VG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407VG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546 --diag_suppress=1295
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Core;../LVGL/LVGL;../LVGL/LVGL/lvgl;../LVGL/LVGL/lvgl/src;../LVGL/LVGL/lvgl/examples/porting;../LVGL/LVGL_APP/demos;../LVGL/LVGL_APP/demos/benchmark;../LVGL/LVGL_APP/demos/music;../LVGL/LVGL_APP/demos/widgets;../LVGL/LVGL_APP/demos/stress;..\LVGL\LVGL_APP\GUI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: lcd.c delay.c sys.c led.c key.c control.c ctiic.c touch.c ads131a04.c main.c gpio.c fsmc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lvgl/examples/porting
    ../LVGL/LVGL/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
    ../LVGL/LVGL/lvgl/: lv_conf.h lvgl.h
  group lvgl/src/core
    ../LVGL/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../LVGL/LVGL/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/LVGL/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../LVGL/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/LVGL/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/LVGL/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/LVGL/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/LVGL/lvgl/src/extra/others/msg/: lv_msg.c
    ../LVGL/LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/LVGL/lvgl/src/extra/: lv_extra.c
  group lvgl/src/font
    ../LVGL/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ../LVGL/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/hal
    ../LVGL/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../LVGL/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../LVGL/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/lvglApp/demos
    ../LVGL/LVGL_APP/demos/benchmark/: lv_demo_benchmark.c
    ../LVGL/LVGL_APP/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group lvgl/lvglApp/demos/Music
    ../LVGL/LVGL_APP/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../LVGL/LVGL_APP/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group lvgl/lvglApp/demos/Widgets
    ../LVGL/LVGL_APP/demos/widgets/: lv_demo_widgets.c
    ../LVGL/LVGL_APP/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group lvgl/lvglApp/demos/stress
    ../LVGL/LVGL_APP/demos/stress/: lv_demo_stress.c
  group lvgl/lvgl_app/gui
    ../LVGL/LVGL_APP/GUI/: gui.c
software components: CMSIS:CORE 4.3.0
